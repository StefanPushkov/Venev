# Keil uVision project CORTEXM4_MY_PROJ.uvproj, settings and files
target FIRST_PROJ (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CORTEXM4_MY_PROJ
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
  group Library
    ./main_libs/: system_stm32f4xx.c stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
    ./main_libs/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h
    ./main_libs/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group title
    ./: title.c
