# Keil uVision project First_proj_f1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: First_proj_f1
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\main;.\F1_main_libs;.\STM32_SPL\inc;.\STM32_SPL\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f10x_md_vl.s
  group libs
    ./F1_main_libs/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h stm32f10x_conf.h stm32f10x_type.h
    ./STM32_SPL/inc/: stm32f10x_gpio.h stm32f10x_rcc.h
    ./STM32_SPL/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group main
    ./: title.c
